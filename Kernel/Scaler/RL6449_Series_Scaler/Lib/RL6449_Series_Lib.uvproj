# Keil uVision project RL6449_Series_Lib.uvproj, settings and files
target RL6449_Series_Base (MCS-51)
  device: DW-8051 Synopsys
  cpu: IRAM(0-0xFF) CLOCK(33000000) MODDP2
  output: RL6449_FunctionLib (library)
  c flags: Optimize=9 SizeSpeed=1
  c define: _TRANSLATOR_SUPPORT = _OFF, _SCALER_TYPE = _RL6449_SERIES
  c include: ..\..\..\Common;..\Header;.\Header;..\..\ScalerFunction\Lib\Header;..\..\ScalerFunction\Header;..\..\ScalerCommonFunction\Lib\Header;..\..\ScalerCommonFunction\Header;..\..\RL6449_Series_Common\Lib\Header;..\..\RL6449_Series_Common\Header
  group Common
    ./Code/: RL6449_AdvancedLib.LIB
  group ScalerCommon
    ../../ScalerCommonFunction/Lib/Header/: ScalerCommonLibInterface.h ScalerCommonLibInternalInclude.h ScalerCommonLibInclude.h
    ../../ScalerCommonFunction/Lib/Code/ScalerCommon/: ScalerCommonTimerPollingDataBitFlagProc.c ScalerCommonComputeDwordMulDiv.c ScalerCommonDebugTimerCursorMS.c ScalerCommonDebugTimerCursorUS.c
  group ScalerCommonNVRam
    ../../ScalerCommonFunction/Lib/Header/: ScalerCommonNVRamLibInternalInclude.h ScalerCommonNVRamLibInclude.h ScalerCommonNVRamLibInterface.h
    ../../ScalerCommonFunction/Lib/Code/ScalerCommonNVRam/: ScalerCommonFlashWrite.c ScalerCommonFlashRead.c
  group ScalerCommonReg
    ../../ScalerCommonFunction/Lib/Header/: ScalerCommonRegLibInternalInclude.h ScalerCommonRegLibInclude.h ScalerCommonRegLibInterface.h
    ../../ScalerCommonFunction/Lib/Code/ScalerCommonReg/: ScalerCommonBurstWrite.c ScalerCommonDataPortAccess.c ScalerCommonDataPortAccessGetDword.c ScalerCommonDataPortAccessGetSingleByte.c ScalerCommonDataPortAccessGetWord.c ScalerCommonDataPortAccessSetDword.c ScalerCommonDataPortAccessSetWord.c ScalerCommonGlobalGetIDCode.c ScalerCommonGlobalGetIDCode_EXINT.c ScalerCommonGlobalGetIDCode_WDINT.c ScalerCommonMultiByteRead.c ScalerCommonMultiByteWrite.c ScalerCommonDataPortAccess_EXINT0.c
  group Scaler
    ../../ScalerFunction/Lib/Code/Scaler/: ScalerMDomainDisplayTimingGenDBEnable.c ScalerScaling.c
  group ScalerColor
    ../../ScalerFunction/Lib/Header/: ScalerColorLibInclude.h ScalerColorLibInterface.h ScalerColorLibInternalInclude.h
    ../../ScalerFunction/Lib/Code/ScalerColor/: ScalerColorBrightnessEnable.c ScalerColorColorimetry.c ScalerColorColorSampling.c ScalerColorContrastEnable.c ScalerColorDCCClrDataReadyStatus.c ScalerColorDCCGetDataReadyStatus.c ScalerColorDCCSetMeasureRegion.c ScalerColorDCRClrDataReadyStatus.c ScalerColorDCRDataRefreshControl.c ScalerColorDCREnable.c ScalerColorDCRGetDataReadyStatus.c ScalerColorDDitherLoadSeqTable.c ScalerColorDigitalFilterEnable.c ScalerColorDigitalFilterEnhancePhaseAdjust.c ScalerColorDigitalFilterExtensionAdjust.c ScalerColorDigitalFilterNRDisableAdjust.c ScalerColorDigitalFilterNRingAdjust.c ScalerColorDigitalFilterNSmearAdjust.c ScalerColorDigitalFilterPRingAdjust.c ScalerColorDigitalFilterPSmearAdjust.c ScalerColorGetColorDepth.c ScalerColorGetColorSpace.c ScalerColorGetColorSpaceRGB.c ScalerColorGetRGBQuantizationRange.c ScalerColorGetYCCQuantizationRange.c ScalerColorHLWBorderAdjust.c ScalerColorHLWBorderEnable.c ScalerColorHLWBRICTS.c ScalerColorHLWDCCAdjust.c ScalerColorHLWDCR.c ScalerColorHLWDDomainAdjust.c ScalerColorHLWDDomainEnable.c ScalerColorHLWGamma.c ScalerColorHLWGlobalHueSat.c ScalerColorHLWICM.c ScalerColorHLWPanelUniformity.c ScalerColorHLWRGB3DGamma.c ScalerColorICMAdjust.c ScalerColorIDither.c ScalerColorIDitherEnable.c ScalerColorPCMInputGammaLoadTable.c ScalerColorRingingFilterOff.c ScalerColorScaling.c ScalerColorSetRGBLimitRange.c ScalerColorSetYCCFullRange.c ScalerColorSpaceConvertDDomainEnable.c ScalerColorSpaceConvertIDomainEnable.c ScalerColorSpaceConvertLoadTable.c ScalerColorSpaceLoadYuv2RgbTable.c ScalerColorGetColorimetry.c ScalerColorGetExtColorimetry.c ScalerColorBrightnessGetSetting.c ScalerColorContrastGetSetting.c ScalerColorWaitDDomainDBApply.c ScalerColorDCCReadResult.c
  group ScalerOD
    ../../ScalerFunction/Lib/Header/: ScalerODLibInclude.h ScalerODLibInterface.h ScalerODLibInternalInclude.h
    ../../ScalerFunction/Lib/Code/ScalerOD/: ScalerODFunction.c
  group ScalerOSD
    ../../ScalerFunction/Lib/Header/: ScalerOSDLibInclude.h ScalerOSDLibInterface.h ScalerOSDLibInternalInclude.h
    ../../ScalerFunction/Lib/Code/ScalerOSD/Command/: OsdAddress90_91_92.c OsdAddressHsbClr.c OsdAddressHsbSet.c OsdBurstWriteDataPort.c OsdFrameControlAllByte.c OsdFrameControlByte.c OsdFrameControlByteGet.c OsdWriteAllByte.c OsdWriteByte.c OsdWriteProtection.c
    ../../ScalerFunction/Lib/Code/ScalerOSD/Function/: Osd2FontFunction.c OsdCircuitActivated.c OsdEnableDisable.c OsdFontWindowVericalAlignemnt.c OsdGetDoubleFunctionH.c OsdGetDoubleFunctionV.c OsdGetEnable.c OsdGetHorizontalDelayStep.c OsdGlobalDoubleBuffer.c OsdHorizontalDelayStep.c OsdPopOn.c OsdPositionOffsetVerticalAlignByDVBGStart.c OsdReferenceDelay.c OsdRollUp.c OsdSetColorPalette.c OsdSetTransparencyType.c OsdSpecificColorBlending.c OsdVerticalStartSelect.c
    ../../ScalerFunction/Lib/Code/ScalerOSD/SRAM/: Osd1BitFontShrink.c Osd2BitFontByte1Bit7Swap.c Osd2BitFontOffset.c OsdAlignMark.c OsdBlankCommandColorExtension.c OsdBlankFont.c OsdChange1BitColor.c OsdChange1BitColorFont256_511.c OsdChange2BitColor.c OsdChange2BitColor16_31.c OsdChange4BitColor.c OsdCharacterWidth.c OsdCharCommandAllByteSeries.c OsdCharCommandByteSeries.c OsdCharShadowBorderColor.c OsdCommandAllByte.c OsdCommandByte.c OsdCompressionCtrl.c OsdFontLibraryRotation.c OsdFontMaskOnOff.c OsdFontMaskRegionOnOff.c OsdFontMaskRegionSet.c OsdReference4BitBackground.c OsdRowHeight.c OsdScrambleDoubleBufferDepth.c OsdSetBlinking.c OsdSramAddressCount.c OsdSramAddressSet.c OsdSramDataValue.c OsdSramDataValue2Byte.c OsdSramGetData.c
    ../../ScalerFunction/Lib/Code/ScalerOSD/Windows/: OsdDrawGridLine.c OsdDrawWindow.c OsdDrawWindowStartOffset.c OsdRotationWindowSize.c OsdRoundedWindow.c OsdRoundedWindowOnOff.c OsdRoundedWindowPattern8x8.c OsdRoundedWindowPattern16x16.c OsdRoundedWindowPattern32x32.c OsdWindow6SpecialFunction.c OsdWindow7SpecialFunction.c OsdWindowChessboard.c OsdWindowDisable.c OsdWindowGradientLevel.c OsdWindowGradientStep.c OsdWindowGrayLevel.c OsdWindowHighlightFunction.c OsdWindowOnOFF.c OsdWindowPriority.c OsdWindowSaturatedColorSelect.c OsdWindowSpecialColorMask.c
  group ScalerTcon
    ../../ScalerFunction/Lib/Header/: ScalerTconLibInclude.h ScalerTconLibInterface.h ScalerTconLibInternalInclude.h
    ../../ScalerFunction/Lib/Code/ScalerTcon/: ScalerTconGlobalEnable.c ScalerTconEnable.c
  group RL6449_Series_Color
    ./Header/: RL6449_Series_ColorLibInclude.h RL6449_Series_ColorLibInterface.h RL6449_Series_ColorLibInternalInclude.h
    ./Code/RL6449_Series_Color/: RL6449_Series_ColorBrightnessAdjust.c RL6449_Series_ColorColorConversion.c RL6449_Series_ColorColorConversionUltraVividSupport.c RL6449_Series_ColorContrastAdjust.c RL6449_Series_ColorDCCAdjust.c RL6449_Series_ColorDCCEnable.c RL6449_Series_ColorDCCGetHistoInfo.c RL6449_Series_ColorDCCHistoSetting.c RL6449_Series_ColorDCCNormalizeFactorAdjust.c RL6449_Series_ColorDCRAdjust.c RL6449_Series_ColorDCRGetAverage.c RL6449_Series_ColorDCRReadResult.c RL6449_Series_ColorDDither.c RL6449_Series_ColorDDitherAdvance.c RL6449_Series_ColorGlobalHueSat.c RL6449_Series_ColorGlobalHueSatEnable.c RL6449_Series_ColorHLWBRICTS.c RL6449_Series_ColorHLWIAPSGain.c RL6449_Series_ColorHLWPCM.c RL6449_Series_ColorHLWUltraVivid.c RL6449_Series_ColorHLWUltraVividAdjust.c RL6449_Series_ColorIAPSGainEnable.c RL6449_Series_ColorIAPSGainSoftClampAdjust.c RL6449_Series_ColorIAPSGainValueAdjust.c RL6449_Series_ColorICMBRILoadTable.c RL6449_Series_ColorICMEnable.c RL6449_Series_ColorICMUVOffsetLoadTable.c RL6449_Series_ColorIDitherResetFrameCnt.c RL6449_Series_ColorOutputGammaAdjust.c RL6449_Series_ColorOutputGammaChannelCtrl.c RL6449_Series_ColorOutputGammaEnable.c RL6449_Series_ColorPanelUniformityAdjust.c RL6449_Series_ColorPanelUniformityEnable.c RL6449_Series_ColorPanelUniformityLDEnable.c RL6449_Series_ColorPanelUniformityLDTargetLUTAdjust.c RL6449_Series_ColorPCM.c RL6449_Series_ColorPCMInputGammaAdjust.c RL6449_Series_ColorPCMInputGammaEnable.c RL6449_Series_ColorPCMOutputGammaAdjust.c RL6449_Series_ColorPCMSRGBAdjust.c RL6449_Series_ColorPCMTable.c RL6449_Series_ColorRGB3DGamma.c RL6449_Series_ColorRGB3DGammaEnable.c RL6449_Series_ColorRGB3DGammaSwapEnable.c RL6449_Series_ColorRGBOutputGammaAdjust.c RL6449_Series_ColorRGBOutputGammaEnable.c RL6449_Series_ColorRGBOutputGammaInitial.c RL6449_Series_ColorRingingFilterAdjust.c RL6449_Series_ColorSampling420to422D2D3Enable.c RL6449_Series_ColorSCMAdjust.c RL6449_Series_ColorSCMLoadTable.c RL6449_Series_ColorSetScalingDownMaskLSB.c RL6449_Series_ColorSixColorAdjust.c RL6449_Series_ColorSixColorInitial.c RL6449_Series_ColorUltraVividAdjust.c RL6449_Series_ColorUltraVividEnable.c RL6449_Series_ColorUltraVividGetStatus.c RL6449_Series_ColorUltraVividSetDisable.c RL6449_Series_ColorPanelUniformityDecayAdjust.c RL6449_Series_ColorPanelUniformityOffsetAdjust.c RL6449_Series_ColorPanelUniformityOffsetEnable.c RL6449_Series_ColorSRGBSwap.c RL6449_Series_ColorSixColorAdjustBriCompensate.c RL6449_Series_ColorSixColorInitialBriCompensate.c RL6449_Series_ColorUltraVividInitial.c RL6449_Series_ColorDCRLocalDimmingEnable.c RL6449_Series_ColorDCRLocalDimmingReadResult.c RL6449_Series_ColorDCRLocalDimmingSetMode.c RL6449_Series_ColorDCRLocalDimmingSetTCon.c RL6449_Series_ColorDDomainDBApply.c RL6449_Series_ColorDDomainDBEnable.c RL6449_Series_ColorDDomainDBStatus.c RL6449_Series_ColorDDomainDBTriggerEvent.c RL6449_Series_ColorDCCGetSceneChangeStatus.c RL6449_Series_ColorPanelUniformityLDSramToggle.c RL6449_Series_ColorPanelUniformityGetLDStatus.c RL6449_Series_ColorDCRGetMaxRGB.c RL6449_Series_ColorSRGBAdjust.c RL6449_Series_ColorDCRGetLocalDimmingHistoEnable.c RL6449_Series_ColorDCRLocalDimmingStoreResult.c RL6449_Series_ColorDCRLocalDimmingReadTHDResult.c RL6449_Series_ColorGlobalDoubleBufferStatus.c RL6449_Series_ColorLDSRGBAdjust.c RL6449_Series_ColorMdomainForceYUV.c RL6449_Series_ColorConvertHueSat.c
  group RL6449_Series_DP
    ./Code/RL6449_Series_DP/: RL6449_Series_DpGetAudioStream.c RL6449_Series_DpGetVideoStream.c
  group RL6449_Series_Memory
    ./Header/: RL6449_Series_MemoryLibInclude.h RL6449_Series_MemoryLibInterface.h RL6449_Series_MemoryLibInternalInclude.h
    ./Code/RL6449_Series_Memory/: RL6449_Series_MemoryFunction.c
  group RL6449_Series_OD
    ./Header/: RL6449_Series_ODLibInclude.h RL6449_Series_ODLibInterface.h RL6449_Series_ODLibInternalInclude.h
    ./Code/RL6449_Series_OD/: RL6449_Series_ODFunction.c RL6449_Series_ODGetStatus.c
  group RL6449_Series_Osd
    ./Header/: RL6449_Series_OSDLibInclude.h RL6449_Series_OSDLibInterface.h RL6449_Series_OSDLibInternalInclude.h
    ./Code/RL6449_Series_OSD/Function/: RL6449_Series_OsdPosition.c RL6449_Series_OsdPositionOffsetCorrection.c RL6449_Series_OsdSetTransparency.c RL6449_Series_OsdSetTransparency_Timer.c RL6449_Series_OsdVerticalBoundaryFunction.c RL6449_Series_OsdScaleUp.c RL6449_Series_OsdScaleUpOnOff.c
    ./Code/RL6449_Series_OSD/SRAM/: RL6449_Series_Osd4BitFontOffset.c RL6449_Series_OsdAutoRotateFontBStartAddr.c RL6449_Series_OsdFont24x36OnOff.c RL6449_Series_OsdFontRotateCtrl.c RL6449_Series_OsdHardwareCompression.c RL6449_Series_OsdHardwareVLC.c RL6449_Series_OsdSramBaseAddressSet.c
  group RL6449_Series_Reg
    ./Header/: RL6449_Series_RegLibInclude.h RL6449_Series_RegLibInterface.h RL6449_Series_RegLibInternalInclude.h
  group RL6449_Series_Tcon
    ./Header/: RL6449_Series_TconLibInclude.h RL6449_Series_TconLibInterface.h RL6449_Series_TconLibInternalInclude.h
    ./Code/RL6449_Series_Tcon/: RL6449_Series_Tcon0.c RL6449_Series_Tcon1.c RL6449_Series_Tcon2.c RL6449_Series_Tcon3.c RL6449_Series_Tcon4.c RL6449_Series_Tcon5.c RL6449_Series_Tcon6.c RL6449_Series_Tcon7.c RL6449_Series_Tcon8.c RL6449_Series_Tcon9.c RL6449_Series_Tcon10.c RL6449_Series_Tcon11.c RL6449_Series_Tcon12.c RL6449_Series_Tcon13.c RL6449_Series_Tcon0Invert.c RL6449_Series_Tcon1Invert.c RL6449_Series_Tcon2Invert.c RL6449_Series_Tcon3Invert.c RL6449_Series_Tcon4Invert.c RL6449_Series_Tcon5Invert.c RL6449_Series_Tcon6Invert.c RL6449_Series_Tcon7Invert.c RL6449_Series_Tcon8Invert.c RL6449_Series_Tcon9Invert.c RL6449_Series_Tcon10Invert.c RL6449_Series_Tcon11Invert.c RL6449_Series_Tcon12Invert.c RL6449_Series_Tcon13Invert.c
  group RL6449_Series_Auto
    ./Code/RL6449_Series_Auto/: RL6449_Series_AutoMeasureColorValue.c
