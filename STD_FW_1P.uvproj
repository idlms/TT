# Keil uVision project STD_FW_1P.uvproj, settings and files
target RL6449_Project (MCS-51)
  device: DW-8051 Synopsys
  cpu: IRAM(0-0xFF) CLOCK(33000000) MODDP2
  output: RL6449_Project +hex (library)
  BeforeMake: .\Tool\precompile\pch_support.bat @L STD_FW_1P.uvproj "" "$K"
  AfterMake: ".\Tool\build\link.bat" "$K" STD_FW_1P.uvproj @L
  c flags: Optimize=9 SizeSpeed=1
  c define: _PROJECT = _RL6449_PROJECT, _SCALER_TYPE = _RL6449_SERIES
  c include: .\Output\RL6449;.\Project\Header;.\Pcb;.\Panel;.\Kernel\Device\Header;.\Kernel\Common;.\Kernel\System\Header;.\Kernel\Scaler\ScalerFunction\Header;.\Kernel\Scaler\ScalerCommonFunction\Header;.\Kernel\Scaler\ScalerFunction\Lib\Header;.\Kernel\Scaler\ScalerCommonFunction\Lib\Header;.\Kernel\Scaler\RL6449_Series_Scaler\Header;.\Kernel\Scaler\RL6449_Series_Scaler\Lib\Header;.\Kernel\Scaler\RL6449_Series_Common\Header;.\Kernel\Scaler\RL6449_Series_Common\Lib\Header;.\Kernel\User Common Function\Header;.\User\RTD Series\RTD2014Function\Header;.\User\RTD Series\RTD2014Osd\Header;.\User\RTD Factory\Header;.\User\None Series\NoneFunction\Header;.\User\None Series\NoneOsd\Header;.\User\None Factory\Header;.\User\User Device\Header
  asm misc: DEFINE(_PROJECT=_RL6449_PROJECT,_SCALER_TYPE=_RL6449_SERIES)
  asm include: .\Project\Header;.\Kernel\Common
  group Project
    ./Project/Header/: User_Project_List.h User_Project_Include.h User_Project_Option.h User_Scaler_Option.h RL6449_Project.h
    ./Kernel/Common/: RL6449_Project_Default.h
  group Pcb
    ./Pcb/: User_Pcb_List.h User_Pcb_Include.h User_Pcb_Option.h
    ./Pcb/RL6449/LQFP_216/: RL6449_PCB_EXAMPLE_216_PIN.h RL6449_DEMO_A_1A2MHL1DP1mDP_DPTX_eDP.h RL6449_DEMO_B_1A2MHL1DP1mDP_DPTX_eDP.h RL6449_DEMO_C_1A2MHL1DP1mDP_DPTX_eDP.h RL6449_DEMO_C_1A2MHL1DP1mDP_DPTX_eDP_PINSHARE.h RL6449_DEMO_D_1A2MHL1DP1mDP_DPTX_eDP.h RL6449_DEMO_E_1A1H1DP_DPTX_eDP.h RL6449_DEMO_F_1A2MHL1DP1mDP_DPTX_VB1.h
  group Common
    ./Kernel/Common/: reg52_RTD.h L51_bank.a51 STARTUP.a51 C_STARTUP.a51 Debug.h Global.h Project.h Scaler_Test_Function.h RL6369_Gen_Option.h RL6369_Project_Default.h RL6369_Pcb_Default.h RL6410_Gen_Option.h RL6410_Project_Default.h RL6410_Pcb_Default.h RL6432_Gen_Option.h RL6432_Project_Default.h RL6432_Pcb_Default.h RL6463_Gen_Option.h RL6463_Project_Default.h RL6463_Pcb_Default.h
  group Panel
    ./Kernel/Common/: Panel_Option.h
    ./Panel/: User_Panel_List.h User_Panel_Include.h User_Panel_Option.h PANEL_NONE.c
    ./Panel/EXAMPLE/: PANEL_LVDS_EXAMPLE.h PANEL_DPTX_EXAMPLE.h PANEL_VBO_EXAMPLE.h
  group System
    ./Kernel/System/Header/: SysInterface.h SysInclude.h
    ./Kernel/System/Code/: SysAudio.c SysDP.c SysInt.c SysJudge.c SysMain.c SysMHL.c SysMode.c SysPower.c SysSource.c SysTimer.c SysTMDS.c SysVGA.c SysColor.c SysTypeC.c SysAutotest.c SysCec.c SysUart.c
  group ScalerFunction
    ./Kernel/Scaler/ScalerFunction/Header/: ScalerFunctionCommonInclude.h ScalerFunctionInclude.h ScalerFunctionInterface.h ScalerMemoryInclude.h
    ./Kernel/Scaler/ScalerFunction/Code/: ScalerADC.c ScalerAudio.c ScalerAutoFunc.c ScalerColor.c ScalerDDomain.c ScalerDDR1.c ScalerDDR3.c ScalerDisplay.c ScalerDisplayDPTx.c ScalerDPRxMST.c ScalerDPRx0.c ScalerDPRx0HDCP2.c ScalerDPRx1HDCP2.c ScalerDPTx.c ScalerDPTxHDCP2.c ScalerDualLinkDVI.c ScalerFormatConversion.c ScalerFRC.c ScalerGDIPhyTx.c ScalerGlobal.c ScalerIDomain.c ScalerIR.c ScalerLCTank.c ScalerMbr.c ScalerMcu.c ScalerMDomain.c ScalerMeasure.c ScalerMemory.c ScalerOD.c ScalerOsd.c ScalerPinshare.c ScalerPLL.c ScalerPower.c ScalerRotation.c ScalerReg.c ScalerSDRAM.c ScalerSync.c ScalerSyncProc.c ScalerTimerFunction.c ScalerVGATop.c ScalerVGIP.c ScalerCec.c
  group ScalerFunction_ComboPhy
    ./Kernel/Scaler/ScalerFunction/Code/: ScalerAudio_ComboPhy.c ScalerDP_ComboPhy.c ScalerDPRx0_ComboPhy.c ScalerDPRx0_INT_ComboPhy.c ScalerTMDS_ComboPhy.c
  group ScalerFunction_SeptPhy
    ./Kernel/Scaler/ScalerFunction/Code/: ScalerAudio_SeptPhy.c ScalerDP_SeptPhy.c ScalerDPRx0_INT_SeptPhy.c ScalerDPRx0_SeptPhy.c ScalerDPRx1_INT_SeptPhy.c ScalerDPRx1_SeptPhy.c ScalerDPRx1HDCP2_SeptPhy.c ScalerDPRxMST_SeptPhy.c ScalerMHL3Rx2_SeptPhy.c ScalerMHL3Rx3_SeptPhy.c ScalerMHLRx2_SeptPhy.c ScalerMHLRx3_SeptPhy.c ScalerMHLRx4_SeptPhy.c ScalerMHLRx5_SeptPhy.c ScalerTMDSRx1_SeptPhy.c ScalerTMDSRx1HDCP2_SeptPhy.c ScalerTMDSRx2_SeptPhy.c ScalerTMDSRx2HDCP2_SeptPhy.c ScalerTMDSRx3_SeptPhy.c ScalerTMDSRx3HDCP2_SeptPhy.c ScalerTMDSRx4_SeptPhy.c ScalerTMDSRx4HDCP2_SeptPhy.c ScalerTMDSRx5_SeptPhy.c ScalerTMDSRx5HDCP2_SeptPhy.c
  group ScalerCommonFunction
    ./Kernel/Scaler/ScalerCommonFunction/Header/: ScalerCommonFunctionCommonInclude.h ScalerCommonFunctionInclude.h ScalerCommonFunctionInterface.h
    ./Kernel/Scaler/ScalerCommonFunction/Code/: ScalerCommonColor.c ScalerCommonDebug.c ScalerCommonDPRx0.c ScalerCommonDPRx0HDCP2.c ScalerCommonDPRx1.c ScalerCommonDPRx1HDCP2.c ScalerCommonDPRxMST.c ScalerCommonDPTx.c ScalerCommonDPTxAux.c ScalerCommonDPTxHDCP2.c ScalerCommonDPTxMST.c ScalerCommonFreeSync.c ScalerCommonHDCP2.c ScalerCommonIOSC.c ScalerCommonMcu.c ScalerCommonMeasure.c ScalerCommonNVRam.c ScalerCommonPLL.c ScalerCommonPower.c ScalerCommonReg.c ScalerCommonSpi.c ScalerCommonSync.c ScalerCommonTimerFunction.c ScalerCommonTMDS.c ScalerCommonTypeC.c ScalerCommonTypeCPmic.c ScalerCommonTypeCPower.c ScalerCommonTypeCRx0Cc.c ScalerCommonTypeCRx0Pd.c ScalerCommonUSB3Retimer.c ScalerCommonFwInfo.c ScalerCommonDpAdaptiveSync.c ScalerCommonFwCheck.c ScalerCommonFwUpdate.c ScalerCommonFwUpdateBackground.c ScalerCommonFwUpdateForeground.c
  group RL6449_Series_Scaler
    ./Kernel/Scaler/RL6449_Series_Scaler/Lib/Output/: RL6449_FunctionLib.LIB
    ./Kernel/Scaler/RL6449_Series_Scaler/Header/: RL6449_Series_FunctionCommonInclude.h RL6449_Series_FunctionInclude.h RL6449_Series_FunctionInterface.h
    ./Kernel/Scaler/RL6449_Series_Scaler/Code/: RL6449_Series_ADC.c RL6449_Series_Audio.c RL6449_Series_Color.c RL6449_Series_DDomain.c RL6449_Series_DDR2.c RL6449_Series_Display.c RL6449_Series_DisplayDPTx.c RL6449_Series_DP.c RL6449_Series_DP_INT.c RL6449_Series_DPRx0.c RL6449_Series_DPRx0_INT.c RL6449_Series_DPRx1.c RL6449_Series_DPRx1_INT.c RL6449_Series_DPRxMST.c RL6449_Series_DPTx.c RL6449_Series_DPTxMST.c RL6449_Series_FormatConversion.c RL6449_Series_FRC.c RL6449_Series_GDIPhy.c RL6449_Series_Global.c RL6449_Series_IDomain.c RL6449_Series_LDO.c RL6449_Series_Mcu.c RL6449_Series_MDomain.c RL6449_Series_Measure.c RL6449_Series_Memory.c RL6449_Series_MHL.c RL6449_Series_MHLRx2.c RL6449_Series_MHLRx3.c RL6449_Series_OD.c RL6449_Series_Osd.c RL6449_Series_Pinshare.c RL6449_Series_PLL.c RL6449_Series_Power.c RL6449_Series_QC_BIST.c RL6449_Series_QC_Color_DDomain.c RL6449_Series_QC_Color_DDomain_II.c RL6449_Series_QC_Color_DDomain_III.c RL6449_Series_QC_Color_DDomain_IV.c RL6449_Series_QC_Color_DDomain_V.c RL6449_Series_QC_Color_IMDomain.c RL6449_Series_QC_Common.c RL6449_Series_QC_DSPC.c RL6449_Series_QC_Main.c RL6449_Series_QC_OD_FRC.c RL6449_Series_QC_OSD.c RL6449_Series_Rotation.c RL6449_Series_Scaling.c RL6449_Series_Sync.c RL6449_Series_SyncProc.c RL6449_Series_TCON.c RL6449_Series_TimerFunction.c RL6449_Series_TMDS.c RL6449_Series_TMDSRx2.c RL6449_Series_TMDSRx3.c RL6449_Series_VGATop.c RL6449_Series_VGIP.c
  group RL6449_Series_Common
    ./Kernel/Scaler/RL6449_Series_Common/Header/: RL6449_Series_Common_FunctionCommonInclude.h RL6449_Series_Common_FunctionInterface.h RL6449_Series_Common_FunctionInclude.h
    ./Kernel/Scaler/RL6449_Series_Common/Code/: RL6449_Series_Common_Reg.c
  group UserCommonFunction
    ./Kernel/User Common Function/Header/: UserCommonInclude.h UserCommonInterface.h UserCommonDdcciDefine.h
    ./Kernel/User Common Function/Code/: UserCommonAdjust.c UserCommonAuto.c UserCommonDdcciFunction.c UserCommonDisplayCalibrationGen0.c UserCommonDisplayCalibrationGen1.c UserCommonInterface.c UserCommonHDR.c UserCommonLocalDimming.c UserCommonModeSearch.c UserCommonNVRamSystem.c UserCommonTypecCommunication.c UserCommonPortControllerEmbedded.c UserCommonPortControllerRts5400.c UserCommonPortControllerUser.c UserCommonUsbHubUser.c UserCommonUsbHubRts5411.c UserCommonScalerDataExchange.c UserCommonSeamlessChg.c UserCommonPortControllerCommon.c UserCommonGlobalDimming.c UserCommonCec.c UserCommonDualBankUser.c UserCommonDualBankUserTable.c UserCommonDualBankUserTableII.c UserCommonFwUpdate.c UserCommonFwUpdateBackground.c UserCommonFwUpdateCrcTable.c UserCommonFwUpdateForeground.c UserCommonFwUpdatePassword.c UserCommonFwUpdateSignatureTable.c
  group RTD2014Function
    ./User/RTD Series/RTD2014Function/Header/: RTD2014UserInclude.h RTD2014UserModeTable.h
    ./User/RTD Series/RTD2014Function/Code/: RTD2014UserInterface.c RTD2014UserAdjust.c RTD2014UserAdjust3DGamma.c RTD2014UserAdjustOutputGamma.c RTD2014UserAdjustRGBGamma.c RTD2014UserAdjustUniformity.c RTD2014UserTypeCInterface.c RTD2014UserInterfaceHDR.c RTD2014UserInterfaceLocalDimming.c RTD2014UserInterfaceDimming.c RTD2014UserInterfaceGlobalDimming.c RTD2014UserInterfaceCec.c
  group RTD2014Osd
    ./User/RTD Series/RTD2014Osd/Header/: RTD2014Include.h RTD2014TimerInclude.h RTD2014TimerEventIDUser.h RTD2014Project.h RTD2014NVRamOsd.h
    ./User/RTD Series/RTD2014Osd/Header/TextTableBody/: Rtd2014OsdTextTableBody_TextTable.h
    ./User/RTD Series/RTD2014Osd/Code/: RTD2014NVRamOsd.c RTD2014Ddcci.c RTD2014Key.c RTD2014Osd.c RTD2014OsdDisplay.c RTD2014OsdFontProp.c RTD2014OsdFontTable.c RTD2014OsdFontVLC.c RTD2014OsdFunc.c RTD2014OsdPalette.c RTD2014OsdWindow.c RTD2014OsdFontDynamicIcon_1.c RTD2014OsdFontDynamicIcon_2.c RTD2014OsdPropPutStringFontTable.c
  group UserDevice
    ./User/User Device/Header/: UserDeviceInclude.h UserExternalDeviceIIC.h ADT7470.h MAX31785.h CM32181.h OLED.h
    ./User/User Device/Code/: UserExternalDeviceIIC.c ADT7470.c MAX31785.c CM32181.c OLED.c
